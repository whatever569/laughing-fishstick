# Keil uVision project project.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.1
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CLOCK_SETUP=1
  c include: ..\Source\acuator;..\Source
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group eeprom
    ../Source/eeprom/: at24c256.h i2c0.c i2c0.h at24c256.cpp
  group PC communication
    ../Source/pc communication/Microcontroller/: queue.c queue.h uart0.c uart0.h dataMC.h dataMC.cpp
  group actuator
    ../Source/acuator/: servo.h servo.c
  group GameStateMachineFunctions
    ../Source/GameStateMachineFunctions/: S_ENDGAME.cpp S_ERROR.cpp S_HOT_COLD.cpp S_Init.cpp S_NO.cpp S_QRCODE.cpp S_SEARCH.cpp S_SETUP.cpp S_WAYPOINT.cpp
  group general
    ../Source/: Initializers.h RandomNumberGenerator.cpp Controls.h GameData.h GPSLocation.h RandomNumberGenerator.h StateMachineInternals.h User.h main.cpp delay.h GameData.cpp delay.cpp
    ../source/: Controls.cpp Initializers.cpp User.cpp
  group GPS
    ../Source/GPS/: GPS.c GPS.h
  group Display
    ../Source/display/: Display.cpp Display.h fonts.c fonts.h i2c1.c i2c1.h ssd1306.h ssd1306.cpp
  group temprature
    ../source/temprature/: temp.h temp.cpp
software components: CMSIS:CORE 5.6.0, Device:Startup 2.5.0
